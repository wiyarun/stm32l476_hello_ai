# Keil uVision project STM32_Ex02_AI_API_TEST.uvprojx, settings and files
target STM32_Ex02_AI_API_TEST (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L476VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STM32_Ex02_AI_API_TEST +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4,__FPU_PRESENT=1,USE_HAL_DRIVER,STM32L476xx
  c include: ../Inc;  ../Drivers/STM32L4xx_HAL_Driver/Inc;  ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;  ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;  ../Drivers/CMSIS/Include;  ../Middlewares/ST/Application/Validation/Inc;../Middlewares/ST/AI/AI/include;../Middlewares/ST/AI/AI/data
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: main.c app_x-cube-ai.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/CMSIS/DSP_Lib/Source/BasicMathFunctions
    ../Drivers/CMSIS/DSP_Lib/Source/BasicMathFunctions/: arm_dot_prod_f32.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c
  group Lib
    ../Middlewares/ST/AI/AI/lib/: network_runtime.lib
  group Middlewares/X-CUBE-AI/Artificial Intelligence/Application/Validation
    ../Src/: aiPredictation.c
    ../Middlewares/ST/Application/Validation/Src/: aiPbMgr.c aiTestUtility.c aiValidation.c pb_common.c pb_decode.c pb_encode.c stm32msg.pb.c
  group Middlewares/ST/AI/AI/data
    ../Middlewares/ST/AI/AI/data/: har_model_data.c network_data.c
  group Middlewares/ST/AI/AI/src
    ../Middlewares/ST/AI/AI/src/: har_model.c network.c
software components: CMSIS:CORE 4.3.0
